## at_monitor/build/Kconfig/Kconfig.shield.defconfig
```kconfig
osource "c:/nordic/boards/shields/*/Kconfig.defconfig"
osource "C:/ncs/v2.5.1/nrf/boards/shields/*/Kconfig.defconfig"
```
